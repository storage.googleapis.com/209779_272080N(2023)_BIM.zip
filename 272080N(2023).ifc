Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2023-06-23T20:04:08
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jun 23 20:04:08 2023 * Host: DESKTOP-RBR1KM2 * Database: C:\Users\andre\AppData\Local\Temp\a8b81a45-bc04-4638-93d5-d3fb21c8155a\d341fa27-9a71-43c7-9220-22059708d687\ifc * Database version: 5507 * Database creation date: Fri Jun 23 20:04:07 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jun 23 20:04:07 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jun 23 20:04:07 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcFlowController: 272080N Overhead shower, d 250 mm, 272080N(2023):272080N Overhead shower, d 250 mm:93014
In: Level 1
Type - PredefinedType: FAUCET
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - NominalDepth: 249.983 mm; NominalHeight: 51.9649 mm; NominalWidth: 249.983 mm
Type - General - Author: BIMStone; BIMObjectName: 272080N(2023); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Shower mixers; NBSReference: 45-35-70/335; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_81; Uniclass2015Description: Shower thermostatic water supply sets; Uniclass2015Reference: Pr_40_20_87_81; Version: 1; VersionDate: 01/06/2023
Type - Green Building Properties - EAN Number: 6414150099564; EN Standard: EN1112; ETIM Class Number: EC011616 Parts for sanitary taps; Noise Class 02ls: II (ISO 3822); Sales Package dimensions (LxWxH): 362 x 266 x 62; UNSPSC Class Number: 30181800 Faucet and shower heads, jets and parts and accessories; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/272080N; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL REACH: http://static.oras.com/doc/reach
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/272080N; 3D View: https://static.oras.com/AR/272080N; Catalog Drawing URL: http://static.oras.com/catdrw/272080N; Dimension Drawing URL: http://static.oras.com/dimdrw/272080N; FDV Document URL: http://www.oras.com/datasheet/272080N/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/272080N; Group: Overhead shower; Installation and Maintenance Guide URL: http://static.oras.com/manual/272080N; Interactive AR View URL: https://static.oras.com/AR/272080N; Manufacturer: Oras; Market: International;Finland;Sweden;Denmark;Poland;Estonia;Lithuania;Latvia;Ukraine; Mobile Product Information URL: http://mpi.oras.com/272080N; Model: 272080N Overhead shower, d 250 mm; Name_en: 272080N Overhead shower, d 250 mm; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 272080N; Product Family: Oras Optima; Product Image URL: http://static.oras.com/image/272080N; Product URL: http://static.oras.com/272080N; Technical DataSheet URL: http://www.oras.com/datasheet/272080N/en; Type Name: 272080N Overhead shower, d 250 mm; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Connection Size: G1/2; Flow Rate At 300kPa With Flow Reducers: 0.00882867 m3/s; Max. Hot Water Supply: 80 kg/K/s3; Over Head Shower Size: Ø250; Shower Parts: Overhead shower;Anti limescale technology (easy to clean); Shower Spray: Rain; Shower Spray Number: 1 shower spray; Surface treatment: Chrome; Working Pressure: 50 - 500 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 272080N(2023); Features: n/a; Finish: Polished; Grade: n/a; ModelNumber: n/a; ModelReference: 272080N; Name: 272080N Overhead shower, d 250 mm; ReplacementCost: n/a; Shape: Sculptured; Size: 95 x 60 x 245 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.0884724 m2; Volume: 0.00324737 m3
Identity Data - Mark: 37
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 272080N(2023): 272080N Overhead shower, d 250 mm; Family and Type: 272080N(2023): 272080N Overhead shower, d 250 mm; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 272080N(2023): 272080N Overhead shower, d 250 mm; Type Id: 272080N(2023): 272080N Overhead shower, d 250 mm; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
